inherit ccache

BB_DANGLINGAPPENDS_WARNONLY = "1"
