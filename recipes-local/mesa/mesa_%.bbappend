ANY_OF_DISTRO_FEATURES = ""

DEPENDS_append += "libdrm elfutils"