include neutrino-plugins-ni-env.inc

DESCRIPTION = "Small terminal based ascII to unicode converter."
