include neutrino-plugins-tuxbox-env.inc

DESCRIPTION = "An editor which can be called from scripts."
