include neutrino-plugins-ni-env.inc

DESCRIPTION = "=Small plugin to reboot box (via timer)"

SUB_PATH = "scripts-sh/plugins/${PLUGIN_NAME}"
