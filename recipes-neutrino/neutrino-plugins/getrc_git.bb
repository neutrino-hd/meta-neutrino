include neutrino-plugins-tuxbox-env.inc

DESCRIPTION = "Get rc-signals for scripts..."

SRC_URI += " \
	file://${PLUGIN_NAME}/Makefile.am \
"
