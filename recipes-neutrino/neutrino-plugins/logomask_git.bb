include neutrino-plugins-ni-env.inc

DESCRIPTION = "Hide channellogos."
