include neutrino-plugins-tuxbox-env.inc

DESCRIPTION = "Simple graphic file manager known as Tuxbox Commander."
