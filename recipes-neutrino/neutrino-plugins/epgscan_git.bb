include neutrino-plugins-ni-env.inc

DESCRIPTION = "Start or stop collect of EPG-data."

PLUGIN_NAME = "EPGscan"

SUB_PATH = "scripts-sh/plugins/${PLUGIN_NAME}"
