include neutrino-plugins-ni-env.inc

DESCRIPTION = "Automatisches Anlegen von Rec/Zap-Timern"

SUB_PATH = "scripts-sh/plugins/${PLUGIN_NAME}"
