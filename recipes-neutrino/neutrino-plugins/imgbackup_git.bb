include neutrino-plugins-ni-env.inc

DESCRIPTION = "Full image-backup with all settings (usable via local update)"

SUB_PATH = "scripts-sh/plugins/${PLUGIN_NAME}"
