include neutrino-plugins-tuxbox-env.inc

DESCRIPTION = "A terminal controlled message box handler."
