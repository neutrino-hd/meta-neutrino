PACKAGECONFIG_remove = "${PACKAGECONFIG_GL}"

PACKAGECONFIG += "gles2"
