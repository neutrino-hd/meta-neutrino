FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI_append += "file://0001-malloc-Fix-tcache-leak-after-thread-destruction-BZ-2.patch"

