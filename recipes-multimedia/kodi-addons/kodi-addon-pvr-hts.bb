SUMMARY = "Kodi Media Center PVR plugins"
LIC_FILES_CHKSUM = "file://src/client.cpp;beginline=1;endline=17;md5=04bc4d3a030e0668e8626c544c73bef6"

PV = "4.4.19+git${SRCPV}"

KODIADDONPLUGIN = "hts"

require kodi-addon-pvr.inc
require kodi-leia.inc
