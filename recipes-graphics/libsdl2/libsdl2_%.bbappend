

PACKAGECONFIG_append = "alsa arm-neon gles2"

